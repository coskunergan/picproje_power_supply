# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; U8G_WITH_PINLIST
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\u8glib; ..\inc; ..\lib\inc; ..\lib\inc\core; ..\lib\inc\peripherals
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Custom
    ../inc/: pin_config.h
    ../src/: stm32_ub_encoder_tim2.c
    ../lib/src/: stm32f4_discovery.c
  group Note
    ../: README
  group StdLib
    ../lib/src/peripherals/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ./: startup_stm32f4xx.s
    ../src/: system_stm32f4xx.c
  group U8gLib
    ../u8glib/src/: chessengine.c u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_i2c.c u8g_com_io.c u8g_com_null.c u8g_cursor.c u8g_delay.c u8g_dev_ks0108_128x64.c u8g_ellipse.c u8g_font.c u8g_font_data.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pbxh16.c u8g_pbxh24.c u8g_polygon.c u8g_rect.c u8g_rot.c u8g_scale.c u8g_state.c u8g_u16toa.c u8g_u8toa.c u8g_virtual_screen.c
  group User
    ../src/: main.c stm32f4xx_it.c u8g_arm.c
